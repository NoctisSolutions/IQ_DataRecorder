options:
  parameters:
    author: Nuand, LLC <bladeRF@nuand.com>
    category: Custom
    description: A simple RX-only GUI that demonstrates the usage of various RX controls.
    generate_options: qt_gui
    id: bladeRF_rx
    output_language: python
    title: '"Simple bladeRF RX GUI"'
  states: {}

blocks:
- name: bladerf_args
  id: variable
  parameters:
    value: '"bladerf=" + bladerf_selection + ",buffers=" + str(num_buffers) + ",buflen=" + str(buflen) + ",num_xfers=" + str(num_xfers) + ",verbosity="+verbosity'
  states: {}
- name: bladerf_selection
  id: variable
  parameters:
    value: str(instance) if serial == "" else serial
  states: {}
- name: filename
  id: variable
  parameters:
    comment: |-
      creates full path to IQ recording
      and adds timestamp and the 
      'note' variable to the filename
    value: record_file_path+note+"_"+str(int(rx_frequency))+"Hz_"+str(int(rx_sample_rate))+"sps_"+str(int(rx_vga_gain))+"dB_"+".cfile"
  states: {}
- name: gui_bladerf_args
  id: variable_qtgui_label
  parameters:
    gui_hint: 11, 0, 1, 10
    label: '"bladeRF arguments"'
    type: string
    value: bladerf_args
  states: {}
- name: gui_rx_bandwidth
  id: variable_qtgui_range
  parameters:
    gui_hint: 1, 2, 1, 2
    label: Bandwidth
    start: 1.5e6
    step: 0.5e6
    stop: 28e6
    value: rx_bandwidth
  states: {}
- name: gui_rx_frequency
  id: variable_qtgui_range
  parameters:
    gui_hint: 0, 0, 1, 5
    label: Frequency
    start: '0'
    step: 1e6
    stop: 3.8e9
    value: rx_frequency
  states: {}
- name: gui_rx_lna_gain
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 0, 9, 1, 1
    label: LNA Gain
    label0: 0 dB
    label1: 3 dB
    label2: 6 dB
    num_opts: '3'
    option0: '0'
    option1: '3'
    option2: '6'
    type: int
    value: rx_lna_gain
  states: {}
- name: gui_rx_sample_rate
  id: variable_qtgui_range
  parameters:
    gui_hint: 1, 0, 1, 2
    label: Sample Rate
    start: 1.5e6
    step: 500e3
    stop: 40e6
    value: rx_sample_rate
  states: {}
- name: gui_rx_vga_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 0, 5, 1, 4
    label: RX VGA1 + VGA2 Gain
    start: '5'
    step: '1'
    stop: '60'
    value: rx_vga_gain
  states: {}
- name: lo_off
  id: variable
  parameters:
    value: rx_sample_rate/2
  states: {}
- name: note
  id: variable_qtgui_entry
  parameters:
    label: RECORDING NOTE (press enter to update)
    type: string
    value: RECORDING_NOTE
  states: {}
- name: rec_button
  id: variable_qtgui_toggle_switch
  parameters:
    initPressed: 'False'
    label: rec_switch
    pressed: '1'
    released: '0'
    switchOnBackground: red
    type: int
    value: '0'
  states: {}
- name: record_file_path
  id: variable
  parameters:
    comment: defaults to your users home directory
    value: r"C:\Users\davec\data\iq_captures\\"
  states: {}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: '4'
    quad_rate: 48000*4
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: filename
    type: complex
  states: {}
- name: buflen
  id: parameter
  parameters:
    label: Length of buffers, in samples. Should be a multiple of 1024.
    value: '4096'
  states: {}
- name: dc_offset_i
  id: parameter
  parameters:
    label: DC offset compensation for I channel
    type: eng_float
    value: '0'
  states: {}
- name: dc_offset_q
  id: parameter
  parameters:
    label: DC offset compensation for Q channel
    type: eng_float
    value: '0'
  states: {}
- name: import_datetime
  id: import
  parameters:
    imports: from datetime import datetime
  states: {}
- name: import_os
  id: import
  parameters:
    imports: import os
  states: {}
- name: import_time
  id: import
  parameters:
    imports: import time
  states: {}
- name: instance
  id: parameter
  parameters:
    label: 0-indexed device instance describing device to use. Ignored if a serial-number is provided.
    type: intx
    value: '0'
  states: {}
- name: note_0
  id: note
  parameters:
    note: Command line params
  states: {}
- name: note_0_0
  id: note
  parameters:
    note: GUI Controls
  states: {}
- name: num_buffers
  id: parameter
  parameters:
    label: Number of buffers to use
    type: intx
    value: '16'
  states: {}
- name: num_xfers
  id: parameter
  parameters:
    label: Number of maximum in-flight USB transfers. Should be <= (num-buffers / 2).
    type: intx
    value: '8'
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    args: bladerf_args
    bb_gain0: gui_rx_vga_gain
    bw0: gui_rx_bandwidth
    dc_offset_mode0: '1'
    freq0: gui_rx_frequency
    gain0: gui_rx_lna_gain
    gain_mode0: 'False'
    if_gain0: '0'
    iq_balance_mode0: '1'
    sample_rate: gui_rx_sample_rate
    sync: sync
    type: fc32
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.1'
    bw: gui_rx_sample_rate
    fc: gui_rx_frequency
    fftsize: '8192'
    gui_hint: 2, 0, 5, 5
    showports: 'True'
    type: complex
  states: {}
- name: qtgui_ledindicator_0
  id: qtgui_ledindicator
  parameters:
    label: '"RED=RECORDING"'
    offColor: green
    onColor: red
    position: '2'
    state: True if rec_button == 1 else False
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: gui_rx_sample_rate
    fc: gui_rx_frequency
    fftsize: '8192'
    gui_hint: 2, 5, 5, 5
    showports: 'True'
    type: complex
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '32'
    interp: '3'
    type: ccc
  states: {}
- name: rx_bandwidth
  id: parameter
  parameters:
    label: Bandwidth
    short_id: b
    type: eng_float
    value: 1.5e6
  states: {}
- name: rx_frequency
  id: parameter
  parameters:
    label: Frequency
    short_id: f
    type: eng_float
    value: 101.5e6
  states: {}
- name: rx_lna_gain
  id: parameter
  parameters:
    label: RX LNA Gain
    short_id: l
    type: intx
    value: '6'
  states: {}
- name: rx_sample_rate
  id: parameter
  parameters:
    label: Sample Rate
    short_id: s
    type: eng_float
    value: 2e6
  states: {}
- name: rx_vga_gain
  id: parameter
  parameters:
    label: RX VGA1 + VGA2 Gain
    short_id: g
    type: intx
    value: '20'
  states: {}
- name: serial
  id: parameter
  parameters:
    label: bladeRF serial number
    value: '""'
  states: {}
- name: verbosity
  id: parameter
  parameters:
    label: 'libbladeRF log verbosity. Options are: verbose, debug, info, warning, error, critical, silent'
    value: '"info"'
  states: {}

connections:
- [analog_wfm_rcv_0, '0', audio_sink_0, '0']
- [osmosdr_source_0, '0', blocks_file_sink_0, '0']
- [osmosdr_source_0, '0', qtgui_freq_sink_x_0, '0']
- [osmosdr_source_0, '0', qtgui_waterfall_sink_x_0, '0']
- [osmosdr_source_0, '0', rational_resampler_xxx_0, '0']
- [rational_resampler_xxx_0, '0', analog_wfm_rcv_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
