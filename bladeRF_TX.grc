options:
  parameters:
    author: davec
    generate_options: qt_gui
    id: bladeRF_TX
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: tx_freq
  id: variable
  parameters:
    value: 150e6
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: C:\Users\davec\data\iq_captures\RECORDING_NOTE_101500000Hz_2000000sps_20dB_.cfile
    repeat: 'True'
    type: complex
  states: {}
- name: soapy_bladerf_sink_0
  id: soapy_bladerf_sink
  parameters:
    center_freq: tx_freq
    dev_args: bladerf_args
    gain: '35'
    samp_rate: samp_rate
    type: fc32
  states: {}

connections:
- [blocks_file_source_0, '0', soapy_bladerf_sink_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
